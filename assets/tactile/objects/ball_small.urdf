Commit message: update from Amax

File: assets/tactile/objects/ball_small.urdf (robot description, URDF)
Before this commit: robot ball, 1 links, 0 joints
Links:
- link ball: mass 0.05 -> 0.5; geometry collision sphere radius=0.02625; visual sphere radius=0.02625
