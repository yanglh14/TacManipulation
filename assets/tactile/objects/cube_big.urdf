Commit message: update task

File: assets/tactile/objects/cube_big.urdf (robot description, URDF)
Before this commit: robot object, 1 links, 0 joints
Links:
- link object: geometry collision box size=0.06 0.06 0.06; visual box size=0.06 0.06 0.06
